# Keil uVision project projetTR_SPI_Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projetTR_SPI_Slave
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Config_GPIO.c Config_SPI.c main.c Config_GPIO.h Config_SPI.h Config_Global.c
    ../projetTR_SPI_Master/: Config_Global.h
